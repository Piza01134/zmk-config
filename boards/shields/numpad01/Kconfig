## boards/shields/numpad01/Kconfig.defconfig
```kconfig
if SHIELD_NUMPAD01

config ZMK_KEYBOARD_NAME
    default "numpad"

endif # SHIELD_NUMPAD01
```
